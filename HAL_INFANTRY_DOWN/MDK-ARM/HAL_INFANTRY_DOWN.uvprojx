# Keil uVision project HAL_INFANTRY_DOWN.uvprojx, settings and files
target HAL_INFANTRY_DOWN (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HAL_INFANTRY_DOWN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Embedded\senior_struct;..\Embedded\senior\CAN_CHASSIS_TRANSMIT;..\Embedded\senior\CH100;..\Embedded\senior\DJI_MOTOR;..\Embedded\senior\HI220;..\Embedded\senior\HT430;..\Embedded\senior\JUDGE;..\Embedded\senior\LK_TECH;..\Embedded\senior\PM01;..\Embedded\senior\REMOTE;..\APP\BAL\Ins;..\APP\TASK\CHASSIS_TASK\Inc;..\Headfile;..\Drivers\CMSIS\Include;..\Embedded\can_bus;..\APP\TASK\CHASSIS_TASK\Inc;..\APP\BAL\Ins
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Embedded
    ../Embedded/senior_struct/: senior.c
    ../Embedded/senior/PM01/: PM01.c
    ../Embedded/senior/JUDGE/: JUDGE.c
    ../Embedded/senior/DJI_MOTOR/: DJI_MOTOR.c
    ../Embedded/senior/REMOTE/: REMOTE.c
    ../Embedded/senior/CH100/: CH100.c
    ../Embedded/senior/CAN_CHASSIS_TRANSMIT/: can_chassis_transmit.c
    ../Embedded/can_bus/: CanBus.c
    ../Embedded/senior/LK_TECH/: LK_TECH.c
    ../Embedded/senior/HI220/: HI220.c
    ../Embedded/senior/HT430/: HT430.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Headfile
    ../Headfile/: public.h
  group Task
    ../APP/TASK/CHASSIS_TASK/Src/: CHASSIS_TASK.c
  group BAL
    ../APP/BAL/Src/: oldpid.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:I/O:STDERR 1.2.0
