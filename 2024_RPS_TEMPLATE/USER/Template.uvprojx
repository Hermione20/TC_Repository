# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1,__FPU_USED=1, __CC_ARM
  c include: ..\CORE;..\USER;..\README;..\HEADFILE;..\BSP;..\APP\RTOS;..\APP\TASK;..\EMBEDDED;..\STLIB\inc;..\STLIB\src;..\APP\BAL;..\BSP\can\Inc;..\BSP\delay\Inc;..\BSP\usart\Inc;..\APP\BAL\Inc;..\APP\RTOS\Inc;..\APP\TASK\CHASSIS_TASK\Inc;..\APP\TASK\GIMBAL_TASK\Inc;..\APP\TASK\SHOOT_TASK\Inc;..\APP\TASK\CANBUS_TASK\Inc;..\APP\TASK\CHASSIS_TASK\Inc;..\EMBEDDED\Protocol;..\EMBEDDED\Inc;..\EMBEDDED\proto
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c BSP.c
  group TASK
    ../APP/TASK/CANBUS_TASK/Src/: CANBUS_TASK.c
    ../APP/TASK/CHASSIS_TASK/Src/: CHASSIS_TASK.c
  group BAL
    ../APP/BAL/Src/: oldpid.c
  group EMBEDDED
    ../EMBEDDED/Src/: CanBus.c senior.c
    ../EMBEDDED/proto/: protobuf-c.c Recieve.pb-c.c Send.pb-c.c
  group BSP
    ../BSP/can/Src/: can.c
    ../BSP/usart/Src/: usart.c
    ../BSP/delay/Src/: delay.c
  group HEADFILE
    ../HEADFILE/: main.h public.h
  group STLIB
    ../STLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group README
    ../: readme.txt
    ../README/: fifo.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Compiler:I/O:STDERR 1.2.0
